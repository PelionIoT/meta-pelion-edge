SUMMARY = "adds flags to journald.conf in a similar way to the method used by systemd-conf found in the systemd bitbake recipe"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"