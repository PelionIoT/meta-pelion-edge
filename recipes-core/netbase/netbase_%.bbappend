#prepend to take precedence over poky/meta
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
