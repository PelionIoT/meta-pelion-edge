FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
 
SRC_URI_append = " file://enable_IP_set.cfg"
