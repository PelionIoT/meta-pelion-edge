FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
 
SRC_URI_append = " file://xilinx_cpu_idle.cfg"
