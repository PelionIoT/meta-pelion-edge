SRC_URI = "git://github.com/RPi-Distro/firmware-nonfree;branch=buster;protocol=https"
