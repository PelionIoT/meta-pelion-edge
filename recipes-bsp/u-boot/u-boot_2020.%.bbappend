FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://rpi-3b-disable-bt-fix.patch"

