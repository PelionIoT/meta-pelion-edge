RDEPENDS_${PN}_append_raspberrypi3 = " udev-rules-rpi hci-init-rpi"
